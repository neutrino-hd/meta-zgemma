RDEPENDS_${PN}  += "zgemma-qteglfs-platform"
